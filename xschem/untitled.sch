v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {/home/hugodg/projects_sky130/microelectronic/amp-cs/xschem/amp-cs.sym} 340 -10 0 0 {name=x1}
C {vsource.sym} -150 -100 0 0 {name=Vin value=1.8}
C {vsource.sym} -70 -100 0 0 {name=Vdd value=1.8}
C {isource.sym} 30 -100 0 0 {name=Ibias value=200u}
C {gnd.sym} -150 -70 0 0 {name=l1 lab=GND}
C {gnd.sym} -70 -70 0 0 {name=l2 lab=GND}
C {gnd.sym} 30 -70 0 0 {name=l3 lab=GND}
C {gnd.sym} 490 10 0 0 {name=l4 lab=GND}
C {lab_pin.sym} -150 -130 0 0 {name=l5 sig_type=std_logic lab=in}
C {lab_pin.sym} -70 -130 0 0 {name=l6 sig_type=std_logic lab=vd}
C {lab_pin.sym} 30 -130 0 0 {name=l7 sig_type=std_logic lab=a}
C {lab_pin.sym} 490 -10 2 0 {name=l8 sig_type=std_logic lab=a}
C {lab_pin.sym} 490 -30 2 0 {name=l9 sig_type=std_logic lab=vd}
C {lab_pin.sym} 190 -30 0 0 {name=l10 sig_type=std_logic lab=in}
